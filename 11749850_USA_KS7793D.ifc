Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-02T08:29:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 02 08:29:29 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\b85d21fc-eb06-4e74-b20c-b7878fdba2c8\9abc8d34-af38-42d0-b95a-3893ada21d16\ifc * Database version: 5507 * Database creation date: Thu Feb 02 08:29:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 02 08:29:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 02 08:29:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11749850_USA_KS7793D:36779301_USA_11749850_KS7793D, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 36779301_USA_11749850_KS7793D
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 36779301_USA_11749850_KS7793D
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Glass, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_353615
Description: Flow; FlowDirection: SOURCEANDSINK
